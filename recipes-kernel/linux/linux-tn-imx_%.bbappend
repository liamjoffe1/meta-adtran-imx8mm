FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

KERNEL_SRC = "git://github.com/liamjoffe1/kernel.git"
KERNEL_BRANCH = "main"
SRCREV = "${AUTOREV}"

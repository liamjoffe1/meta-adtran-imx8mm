FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCSERVER = "git://github.com/liamjoffe1/u-boot.git"
SRCBRANCH = "main"
SRCREV = "${AUTOREV}"
